# Keil uVision project fatfs0.09.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: systick +hex
  c flags: Optim=4 oTime=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\USER;..\FWlib\inc;..\CMSIS;..\ff9
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c sdio_sdcard.c usart1.c sd_fs_app.c Sd_bmp.c lcd_botton.c lcd.c SysTick.c
  group startup
    ../CMSIS/: startup_stm32f10x_hd.s
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_usart.c stm32f10x_fsmc.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group ff9
    ../ff9/: ff.c diskio.c
    ../ff9/option/: cc936.c
  group Tip
    ../: Readme.txt
